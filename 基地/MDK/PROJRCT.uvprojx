# Keil uVision project PROJRCT.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PROJRCT +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\CORE;..\STM23F10x_FWLIB\inc;..\SYSTEM;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: delay.c can.c gpio.c nvic.c control.c main.c pid.c ramp.c tim.c judge.c dma.c usart.c
  group CORE
    ../CORE/: core_cm3.c
  group FWLIB
    ../STM23F10x_FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_dma.c
  group SYSTEM
    ../SYSTEM/: stm32f10x_it.c system_stm32f10x.c
  group STARTUP
    ../STARTUP/: startup_stm32f10x_hd.s
  group TXT
    ../: ReadMe.txt
