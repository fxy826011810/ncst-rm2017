# Keil uVision project keil.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: keil
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX
  c include: ..\Program\inc;..\Program\Core;..\Program\Mpu6050;..\Program\src;..\Program\System;..\Program\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ../Program/Keil/StartUp/: startup_stm32f40xx.s
  group System
    ../Program/System/: stm32f4xx_it.c system_stm32f4xx.c
  group Task
    ../Program/User/: dbus.c control.c
  group User
    ../Program/User/: main.c key.h key.c
  group Src
    ../Program/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Driver
    ../Program/User/: pid.c ramp.c can.c delay.c dma.c nvic.c gpio.c tim.c usart.c calc.c
