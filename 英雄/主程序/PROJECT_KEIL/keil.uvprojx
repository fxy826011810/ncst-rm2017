# Keil uVision project keil.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: keil +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx
  c include: ..\Program\inc;..\Program\Core;..\Program\Mpu6050;..\Program\src;..\Program\System;..\Program\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Imu
    ../Program/Mpu6050/: mpu6050.c mpu6050_inter.c
  group StartUp
    ../Program/Keil/StartUp/: startup_stm32f427_437xx.s
  group System
    ../Program/System/: stm32f4xx_it.c system_stm32f4xx.c
  group Task
    ../Program/User/: pid.c dbus.c control.c ramp.c
  group User
    ../Program/User/: main.c Infantry.h
  group Src
    ../Program/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_spi.c
  group Driver
    ../Program/User/: can.c delay.c dma.c gpio.c nvic.c tim.c usart.c spi.c judge.c calc.c key.c
  group ReadMe
    ../Program/: ReadMe.txt
